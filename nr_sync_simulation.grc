options:
  parameters:
    author: Mark Disterhof
    copyright: Mark Disterhof
    generate_options: qt_gui
    id: nr_sync_dem
    output_language: python
    title: 5G NR Synchronization Procedure Demo
  states: {}

blocks:
- name: L__max
  id: variable
  parameters:
    value: len(idxs)
  states: {}
- name: N_ID1
  id: variable
  parameters:
    value: '234'
  states: {}
- name: N_ID2
  id: variable
  parameters:
    value: '1'
  states: {}
- name: f
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: idxs
  id: variable
  parameters:
    value: nrphypy.ssb.get_ssb_ids(nrphypy.ssb.get_ssb_candidate_idx(mu, f, shared_spectr, paired_spectr), mu, shared_spectr)
  states: {}
- name: k_ssb
  id: variable
  parameters:
    value: '10'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_dial_control
  parameters:
    gui_hint: (0,2,1,1)
    label: Noise σ [1e-6]
    maximum: 10e4
    minimum: '0'
    outputmsgname: ''
    showvalue: 'True'
    type: real
    value: 60e3
  states: {}
- name: nu
  id: variable
  parameters:
    value: (N_ID2 + 3* N_ID1)%4
  states: {}
- name: num_carr
  id: variable
  parameters:
    value: 2**8
  states: {}
- name: paired_spectr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pbch_data
  id: variable
  parameters:
    value: loadtxt('resource/antbin.txt',dtype=int)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: num_carr * 20
  states: {}
- name: shared_spectr
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise/1e6
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1/num_carr '
    type: complex
    vlen: num_carr
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.000000001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.000000001'
    type: complex
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (len(pbch_data), 864*L__max-len(pbch_data))
    type: int
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '5000'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_carr
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 240*4
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '864'
    type: int
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_carr
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(num_carr)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import nrphypy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from numpy import loadtxt, sqrt
  states: {}
- name: nr_sync_dmrs_decode_0
  id: nr_sync_dmrs_decode
  parameters:
    l_max: L__max
  states: {}
- name: nr_sync_nidcell_ii_0
  id: nr_sync_nidcell_ii
  parameters: {}
  states: {}
- name: nr_sync_pbch_descramble_ci_0
  id: nr_sync_pbch_descramble_ci
  parameters:
    L__max: L__max
  states: {}
- name: nr_sync_pss_sync_cc_0
  id: nr_sync_pss_sync_cc
  parameters:
    L__max: L__max
    fft_size: num_carr
    threshold: '100'
  states: {}
- name: nr_sync_rgrid_c_0
  id: nr_sync_rgrid_c
  parameters:
    N_ID1: N_ID1
    N_ID2: N_ID2
    f: f
    k_ssb: k_ssb
    mu: mu
    n_carr: num_carr
    paired_spectr: paired_spectr
    pbch_data: pbch_data
    shared_spectr: shared_spectr
  states: {}
- name: nr_sync_sss_decode_ci_0
  id: nr_sync_sss_decode_ci
  parameters: {}
  states: {}
- name: nr_sync_unmap_ssb_cc_0
  id: nr_sync_unmap_ssb_cc
  parameters:
    nu: nu
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (2,0,2,2)
    name: '"Rx SSB Constellation"'
    size: 240*4
    type: complex
    update_time: '0.001'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (0,3,1,1)
    max: '0.003'
    min: '0'
    name: '"Signal RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (0,4,1,1)
    max: '0.003'
    min: '0'
    name: '"Noise RMS"'
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0,2,2)
    name: '"Tx Resourcegrid"'
    ncols: num_carr
    nrows: '60'
    samp_rate: samp_rate
    type: float
    update_time: '0.000001'
    x_label: '"Sub-Carrier"'
    y_label: '"Symbols"'
    zmin: '-0'
  states: {}
- name: qtgui_time_raster_sink_x_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    grid: 'True'
    gui_hint: (1,2,3,3)
    ncols: '201'
    nrows: '40'
    samp_rate: samp_rate
    type: float
    update_time: '0.000001'
    x_label: '" "'
    y_label: '" "'
    zmin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulation_chain
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: pbch_sym
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: dmrs_sym
  states: {}
- name: virtual_sink_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: nid_cell
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pbch_proc
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulation_chain
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: nid_cell
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: dmrs_sym
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: pbch_sym
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: pbch_proc
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_fastnoise_source_x_0, '0', blocks_rms_xx_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_raster_sink_x_1_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_rms_xx_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_stream_demux_0, '0', blocks_int_to_float_0_0, '0']
- [blocks_stream_demux_0, '1', blocks_null_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_stream_demux_0, '0']
- [fft_vxx_0, '0', blocks_multiply_const_xx_0, '0']
- [nr_sync_dmrs_decode_0, '0', nr_sync_pbch_descramble_ci_0, '2']
- [nr_sync_nidcell_ii_0, '0', virtual_sink_0_0_1_0_0, '0']
- [nr_sync_pbch_descramble_ci_0, '0', virtual_sink_2, '0']
- [nr_sync_pss_sync_cc_0, '0', nr_sync_nidcell_ii_0, '0']
- [nr_sync_pss_sync_cc_0, '0', nr_sync_sss_decode_ci_0, '0']
- [nr_sync_pss_sync_cc_0, '1', blocks_vector_to_stream_0_0_0, '0']
- [nr_sync_pss_sync_cc_0, '1', nr_sync_unmap_ssb_cc_0, '0']
- [nr_sync_rgrid_c_0, '0', blocks_throttle_0, '0']
- [nr_sync_sss_decode_ci_0, '0', nr_sync_nidcell_ii_0, '1']
- [nr_sync_unmap_ssb_cc_0, '0', nr_sync_sss_decode_ci_0, '1']
- [nr_sync_unmap_ssb_cc_0, '1', virtual_sink_0_0_1, '0']
- [nr_sync_unmap_ssb_cc_0, '2', virtual_sink_0_0_1_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0, '0', blocks_rms_xx_0_0, '0']
- [virtual_source_1, '0', nr_sync_dmrs_decode_0, '0']
- [virtual_source_1, '0', nr_sync_pbch_descramble_ci_0, '0']
- [virtual_source_1_0, '0', nr_sync_dmrs_decode_0, '1']
- [virtual_source_1_0_0, '0', nr_sync_pbch_descramble_ci_0, '1']
- [virtual_source_2, '0', nr_sync_pss_sync_cc_0, '0']
- [virtual_source_3, '0', blocks_vector_to_stream_1, '0']

metadata:
  file_format: 1
